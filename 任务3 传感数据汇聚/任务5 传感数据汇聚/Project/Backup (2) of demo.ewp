# IAR project Backup (2) of demo.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\mylib; ..\CC2530_lib\utils; ..\CC2530_lib\moudle; ..\sensor_drv
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
configuration temprh_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xCC2530_DEBUG
configuration fire_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xCC2530_DEBUG
configuration collect (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xCC2530_DEBUG
  group app
    ./: collect.c fire_sensor.c temprh_sensor.c
  group basicrf
    ../CC2530_lib/basicrf/: basic_rf.r51
  group board
    ../CC2530_lib/board/: hal_adc.c hal_board.c hal_i2c.c hal_led.c hal_pwm.c
  group common
    ../CC2530_lib/common/: hal_clock.c hal_digio.c hal_int.c hal_mcu.c hal_rf.c hal_rf_security.c hal_rf_util.c hal_sleep.c hal_timer_32k.c hal_uart.c hal_uart1.c
  group mylib
    ../CC2530_lib/mylib/: TIMER.c UART_PRINT.c UART_SEND_RECV.c
  group sensor_drv
    ../sensor_drv/: get_adc.c get_swsensor.c sht.c sht1x.c sht3x.c
  group utils
    ../CC2530_lib/utils/: util.c
